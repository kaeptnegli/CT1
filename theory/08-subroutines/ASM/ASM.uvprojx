# Keil uVision project ASM.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: CT Board HS14 M0 STMicroelectronics
  pack: InES.CTBoard14_DFP.0.0.7
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(180000000) ELITTLE
  output: DataTransferASM
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./app/: functionsStack.s
  group ::Device
    RTE/Device/CT_Board_HS14_M0/: system_ctboard.c
    C:/Keil_v5/ARM/PACK/InES/CTBoard14_DFP/0.0.7/Device/Source/: startup_ctboard_asm.s
software components: Device:Startup ASM 0.0.6
