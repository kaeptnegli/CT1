# Keil uVision project logrot.uvproj, settings and files
target Target _asm (ARM-ADS)
  device: CT Board HS14 M0 STMicroelectronics
  pack: InES.CTBoard14_DFP.0.0.7
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(180000000) ELITTLE
  output: arith
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\logrot.sct
  group Source Group 1
    ./app/: trial.c logrot.s
target Target_C (ARM-ADS)
  device: ARMCM0 ARM
  pack: Keil.ARMCortex_DFP.0.0.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(10000000) ELITTLE
  output: trial
  c flags: Optim=1 wLevel=2
  memory RVCT4: ROM 0x2000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\arith.sct
