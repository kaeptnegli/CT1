# Keil uVision project Test_CTHS14.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: CT Board HS14 M0 STMicroelectronics
  pack: InES.CTBoard14_DFP.0.0.7
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(180000000) ELITTLE
  output: Test_CTHS14
  c flags: Optim=1 uC99=1 wLevel=2
  c include: .\app;.\keil
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Keil
    ./keil/: startup_stm32f429x.s
  group app
    ./app/: main.c arrays.c show_variables.c literal_examples.c exercise_variables.c
    ./: cast.c
