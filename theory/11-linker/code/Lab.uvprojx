# Keil uVision project Lab.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: CT Board HS14 M0 STMicroelectronics
  pack: InES.CTBoard14_DFP.3.0.5
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Lab
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress 6314
  group App
    ./App/: main.c
software components: Device:Startup 3.0.5, HAL:ADC 2.2.0, HAL:DMA 2.2.0, HAL:FMC 3.0.1, HAL:GPIO 3.0.3, HAL:PWR 2.2.0, HAL:RCC 3.0.1, HAL:TIMER 3.0.5
