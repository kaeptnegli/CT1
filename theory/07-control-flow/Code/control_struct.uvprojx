# Keil uVision project control_struct.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: CT Board HS14 M0 STMicroelectronics
  pack: InES.CTBoard14_DFP.1.0.1
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: param_passing
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ./app/: code_examples.c control_struct.s scratch.c
  group ::Device
    RTE/Device/CT_Board_HS14_M0/: system_ctboard.c
    C:/Keil_v5/ARM/PACK/InES/CTBoard14_DFP/1.0.1/Device/Source/: startup_ctboard.s utils_ctboard.c
software components: Device:Startup 1.0.0, Device:Utilities 0.0.6
