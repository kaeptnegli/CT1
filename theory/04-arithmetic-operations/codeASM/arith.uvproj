# Keil uVision project arith.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ARMCM0 ARM
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(10000000) ELITTLE
  output: arith
  c flags: Optim=1
  memory RVCT4: ROM 0x2000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\arith.sct
  group Source Group 1
    ./app/: trial.c arith.s
target Target2 (ARM-ADS)
  device: ARMCM0 ARM
  cpu: as above
  output: trial
  c flags: Optim=1 wLevel=2
  memory RVCT4: ROM 0x2000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\arith.sct
