# Keil uVision project param_passing.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: CT_Board_HS14_M0 STMicroelectronics
  pack: InES.CTBoard14_DFP.4.0.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: param_passing
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c misc: --asm
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ./app/: main.c strcopy.s param_in_reg.c
